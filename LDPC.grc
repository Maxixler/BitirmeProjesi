options:
  parameters:
    author: Armağan Bi
    generate_options: qt_gui
    id: LDPC
    output_language: python
    title: LDPC
  states: {}

blocks:
- name: constel
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0, 1, 1, 1]'
    label: Freq Offset
    start: '-0.25'
    step: '0.001'
    stop: '0.25'
    value: '0.01'
  states: {}
- name: hdr
  id: variable
  parameters:
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: ldpc_dec
  id: variable_ldpc_decoder_def
  parameters:
    file: C:\Users\DELL\Downloads\BitirmeProjesi2\n_1296_k_0648_ieee.alist
    max_iter: '50'
    ndim: '0'
  states: {}
- name: ldpc_enc
  id: variable_ldpc_encoder_def
  parameters:
    file: C:\Users\DELL\Downloads\BitirmeProjesi2\n_1296_k_0648_ieee.alist
    ndim: '0'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0, 0, 1, 1]'
    label: Noise
    start: '0.0'
    step: '0.01'
    stop: '2.0'
    value: '0.1'
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '77'
  states: {}
- name: postamble_size
  id: variable
  parameters:
    value: '8'
  states: {}
- name: preamble_size
  id: variable
  parameters:
    value: '250'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0, 2, 1, 1]'
    label: Time Scale
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.0001'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: bpsk_receive.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: bpsk_transmit.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: payload_size
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: preamble_size
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: postamble_size
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '2.0'
    lengthtagname: '"packet_len"'
    type: byte
  states: {}
- name: blocks_tagged_stream_multiply_length_0_1
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '0.5'
    lengthtagname: '"packet_len"'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '4'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: items
    maximum: '512'
    samples_per_second: '8000'
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Preamble
    repeat: 'True'
    type: byte
    vector: '[0xc0, 0xaf]'
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    comment: Postamble
    repeat: 'True'
    type: byte
    vector: '[0xc0, 0xaf]'
  states: {}
- name: channels_channel_model_1
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_additive_scrambler_xx_0
  id: digital_additive_scrambler_xx
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: '7'
    mask: '0x8A'
    reset_tag_key: '"packet_len"'
    seed: '0x7F'
    type: byte
  states: {}
- name: digital_additive_scrambler_xx_0_0
  id: digital_additive_scrambler_xx
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: '7'
    mask: '0x8A'
    reset_tag_key: '"packet_len"'
    seed: '0x7F'
    type: byte
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: constel
    npwr: '-1'
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    tagname: packet_len
    threshold: '0'
    type: float
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: len(constel.points())
    w: 2*3.14/100
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: packet_len
    packed: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr
    len_tag_key: packet_len
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: constel.base()
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '0.1'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\r\nEmbedded Python Block: Soft Differential Decoder\r\nGiris: float32  (soft semboller, Constellation Soft Decoder'dan)\r\nCikis: float32  (soft decoded bitler, LDPC Decoder'a)\r\n\r\nBPSK (modulus=2): out[n] = in[n] * in[n-1]\r\nQPSK (modulus=4): I/Q ciftlerini complex'e cevirip diff decode\r\n\r\nChase Combining icin soft bilgiyi korur.\r\n\"\"\"\r\n\r\nimport numpy as np\r\nfrom gnuradio import gr\r\nimport pmt\r\n\r\n\r\nclass blk(gr.sync_block):\r\n    \"\"\"\r\n    Soft Differential Decoder\r\n\r\n    Differential Decoder'in soft-decision versiyonudur.\r\n    Float soft sembolleri alip soft decoded bitler uretir.\r\n\r\n    Matematiksel temel:\r\n        BPSK:  out[n] = in[n] * in[n-1]\r\n        QPSK:  y[n] = z[n] * conj(z[n-1])\r\n               z[n] = in[2n] + j*in[2n+1]\r\n               out[2n]   = Re(y[n])\r\n               out[2n+1] = Im(y[n])\r\n\r\n    Parametreler:\r\n        modulus: 2 (BPSK) veya 4 (QPSK)\r\n    \"\"\"\r\n\r\n    def __init__(self, modulus=2):\r\n        if modulus not in (2, 4):\r\n            raise ValueError(\r\n                \"Desteklenmeyen modulus: {}. \"\r\n                \"2 (BPSK) veya 4 (QPSK) kullanin.\".format(modulus)\r\n            )\r\n\r\n        self.modulus = int(modulus)\r\n\r\n        gr.sync_block.__init__(\r\n            self,\r\n            name='Soft Diff Decoder',\r\n            in_sig=[np.float32],\r\n            out_sig=[np.float32]\r\n        )\r\n\r\n        # QPSK: her seferde 2 float (I, Q cifti) islensin\r\n        if self.modulus == 4:\r\n            self.set_output_multiple(2)\r\n\r\n        # Onceki sembol referans degeri\r\n        if self.modulus == 2:\r\n            self.prev = np.float32(1.0)\r\n        else:\r\n            self.prev_complex = complex(1.0, 0.0)\r\n\r\n    def work(self, input_items, output_items):\r\n        inp = input_items[0]   # float32 dizisi\r\n        out = output_items[0]  # float32 dizisi\r\n        n = len(inp)\r\n\r\n        if n == 0:\r\n            return 0\r\n\r\n        if self.modulus == 2:\r\n            # --- BPSK: out[n] = in[n] * in[n-1] ---\r\n            extended = np.empty(n + 1, dtype=np.float32)\r\n            extended[0] = self.prev\r\n            extended[1:] = inp\r\n            # Negation: correlate_access_code_ff_ts pozitif=1\r\n            # olarak yorumlar, diff decode ise pozitif=bit0 uretir.\r\n            # Ters cevirme ile uyum saglanir.\r\n            out[:] = -(extended[1:] * extended[:-1])\r\n            self.prev = np.float32(inp[-1])\r\n\r\n        else:\r\n            # --- QPSK: I/Q ciftleri uzerinden complex diff decode ---\r\n            num_symbols = n // 2\r\n\r\n            # Soft I ve Q degerlerinden complex sembol olustur\r\n            I_vals = inp[0::2]\r\n            Q_vals = inp[1::2]\r\n            curr = (I_vals + 1j * Q_vals).astype(np.complex64)\r\n\r\n            # Onceki semboller dizisi\r\n            prev_arr = np.empty(num_symbols, dtype=np.complex64)\r\n            prev_arr[0] = self.prev_complex\r\n            prev_arr[1:] = curr[:-1]\r\n\r\n            # y[k] = curr[k] * conj(prev[k])\r\n            y = curr * np.conj(prev_arr)\r\n\r\n            # Interleaved cikis (negated for polarity match)\r\n            out[0::2] = -(y.real.astype(np.float32))\r\n            out[1::2] = -(y.imag.astype(np.float32))\r\n\r\n            self.prev_complex = complex(curr[-1])\r\n\r\n        return n\r\n"
    modulus: '2'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class feedback_estimator(gr.sync_block):
            def __init__(self):
                gr.sync_block.__init__(
                    self,
                    name="feedback_estimator",
                    in_sig=[np.uint8],
                    out_sig=[np.uint8]
                )
                self.iteration = 0
                self.last_mean = 127.5
                self.adaptation_rate = 0.01

            def work(self, input_items, output_items):
                in0 = input_items[0]
                out = output_items[0]
                out[:] = in0  # Pass-through

                if len(in0) == 0:
                    return len(output_items[0])

                # Simple signal quality estimation
                data_float = np.array(in0, dtype=np.float64)
                current_mean = np.mean(data_float)
                current_var = np.var(data_float)

                mean_error = abs(current_mean - self.last_mean)
                var_error = abs(current_var - 5400.0) / 5400.0
                error_metric = (mean_error / 127.5) + var_error

                self.iteration += 1

                # In a real implementation, you would adjust parameters here
                # For GRC, we'll output a message or use a workaround

                if self.iteration % 100 == 0:
                    print(f"Feedback: iter={self.iteration}, error={error_metric:.4f}")

                return len(output_items[0])
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: ldpc_dec
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: ldpc_enc
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: note_0
  id: note
  parameters:
    note: Receiver
  states: {}
- name: note_1
  id: note
  parameters:
    note: transmitter
  states: {}
- name: note_2
  id: note
  parameters:
    note: Channel simulation
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[1, 0, 4, 3]'
    label1: Real
    label2: Imag
    name: Received Samples
    size: '1024'
    srate: samp_rate
    tr_delay: '0.0'
    tr_tag: ''
    type: complex
    ymax: '1.0'
    ymin: '-1.0'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[5, 0, 4, 3]'
    label1: Real
    label2: Imag
    name: Recovered Symbols
    size: '256'
    srate: samp_rate/sps
    style2: '3'
    tr_delay: '0.0'
    tr_level: '0.01'
    type: complex
    update_time: '0.1'
    ymax: '1.0'
    ymin: '-1.0'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      with open("bpsk_transmit.txt", "w") as f:
          for val in range(0x30, 0x3A):
              payload = chr(val) * self.payload_size
              f.write(payload)
    comment: Create transmit file
    section: init_before_blocks
  states: {}
- name: snippet_1
  id: snippet
  parameters:
    code: |-
      import filecmp

      if filecmp.cmp("bpsk_transmit.txt", "bpsk_receive.txt", shallow=False):
          print("Successful file transfer")
      else:
         print("Error: Transmit and Receive files differ")
    comment: Compare transmit and receive file
    section: main_after_stop
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_packet
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: header
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: transmit
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: channel
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: recovery
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: rx_payload
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: ldpc_payload
  states: {}
- name: virtual_sink_6
  id: virtual_sink
  parameters:
    stream_id: ldpc_rx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx_packet
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: channel
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: recovery
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: rx_payload
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: transmit
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: header
  states: {}
- name: virtual_source_7
  id: virtual_source
  parameters:
    stream_id: ldpc_payload
  states: {}
- name: virtual_source_8
  id: virtual_source
  parameters:
    stream_id: ldpc_rx
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_tag_gate_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle2_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_additive_scrambler_xx_0, '0']
- [blocks_repack_bits_bb_0_0, '0', virtual_sink_5, '0']
- [blocks_repack_bits_bb_1, '0', virtual_sink_6, '0']
- [blocks_repack_bits_bb_1_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0_0, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0_0_0, '0', blocks_tagged_stream_mux_0, '3']
- [blocks_tag_gate_0, '0', virtual_sink_1, '0']
- [blocks_tagged_stream_multiply_length_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', blocks_repack_bits_bb_1_0, '0']
- [blocks_tagged_stream_multiply_length_0_1, '0', digital_additive_scrambler_xx_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0_0_0_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_stream_to_tagged_stream_0_0_0_0_0, '0']
- [channels_channel_model_1, '0', qtgui_time_sink_x_0_0, '0']
- [channels_channel_model_1, '0', virtual_sink_2, '0']
- [digital_additive_scrambler_xx_0, '0', fec_extended_encoder_0, '0']
- [digital_additive_scrambler_xx_0_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_soft_decoder_cf_0, '0', epy_block_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', virtual_sink_4, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_1_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_3, '0']
- [digital_crc32_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_crc32_bb_1, '0', epy_block_1, '0']
- [digital_protocol_formatter_bb_0, '0', virtual_sink_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [epy_block_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [epy_block_1, '0', blocks_file_sink_0, '0']
- [epy_block_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [fec_extended_decoder_0, '0', blocks_tagged_stream_multiply_length_0_1, '0']
- [fec_extended_encoder_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [filter_fft_rrc_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_1, '0', filter_fft_rrc_filter_0, '0']
- [virtual_source_2, '0', digital_constellation_soft_decoder_cf_0, '0']
- [virtual_source_3, '0', fec_extended_decoder_0, '0']
- [virtual_source_4, '0', channels_channel_model_1, '0']
- [virtual_source_5, '0', blocks_tagged_stream_mux_0, '1']
- [virtual_source_7, '0', blocks_tagged_stream_mux_0, '2']
- [virtual_source_8, '0', digital_crc32_bb_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
