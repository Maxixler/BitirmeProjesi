options:
  parameters:
    author: Armağan Bi - Eren Kale
    generate_options: qt_gui
    id: RX_host
    output_language: python
    title: RX_host
  states: {}

blocks:
- name: constel
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: hdr
  id: variable
  parameters:
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: ldpc_dec
  id: variable_ldpc_decoder_def
  parameters:
    file: /home/qrispy/BitirmeProje/n_1296_k_0648_ieee.alist
    max_iter: '10'
    ndim: '0'
  states: {}
- name: ldpc_dec_2
  id: variable_ldpc_decoder_def
  parameters:
    file: /home/qrispy/BitirmeProje/n_1296_k_0648_ieee.alist
    max_iter: '10'
    ndim: '0'
  states: {}
- name: ldpc_enc
  id: variable_ldpc_encoder_def
  parameters:
    file: /home/qrispy/BitirmeProje/n_1296_k_0648_ieee.alist
    ndim: '0'
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '77'
  states: {}
- name: postamble_size
  id: variable
  parameters:
    value: '8'
  states: {}
- name: preamble_size
  id: variable
  parameters:
    value: '250'
  states: {}
- name: preamble_syms
  id: variable
  parameters:
    value: '[complex(1 - 2 * ((b >> (7 - i)) & 1), 0) for b in [0xc0, 0xaf] * 4 for i in range(8)]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/qrispy/BitirmeProje/bpsk_receive.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/qrispy/BitirmeProje/bpsk_receive_2.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.894'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_1
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_multiply_length_0_1
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '0.5'
    lengthtagname: '"packet_len"'
    type: byte
  states: {}
- name: blocks_tagged_stream_multiply_length_0_1_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '0.5'
    lengthtagname: '"packet_len"'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_additive_scrambler_xx_0_0
  id: digital_additive_scrambler_xx
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: '7'
    mask: '0x8A'
    reset_tag_key: '"packet_len"'
    seed: '0x7F'
    type: byte
  states: {}
- name: digital_additive_scrambler_xx_0_0_0
  id: digital_additive_scrambler_xx
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: '7'
    mask: '0xAB'
    reset_tag_key: '"packet_len"'
    seed: '0x55'
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1.0+0j, 1.0+0j]'
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: constel
    npwr: '-1'
  states: {}
- name: digital_constellation_soft_decoder_cf_0_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: constel
    npwr: '-1'
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: len(preamble_syms)-1
    sps: '1'
    symbols: preamble_syms
    threshold: '0.7'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    tagname: packet_len
    threshold: '1'
    type: float
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    tagname: packet_len
    threshold: '1'
    type: float
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: len(constel.points())
    w: 2*3.14/100
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: packet_len
    packed: 'True'
  states: {}
- name: digital_crc32_bb_1_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: packet_len
    packed: 'True'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: constel.base()
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '0.1'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\r\nEmbedded Python Block: Soft Differential Decoder\r\nGiris: float32  (soft semboller, Constellation Soft Decoder'dan)\r\nCikis: float32  (soft decoded bitler, LDPC Decoder'a)\r\n\r\nBPSK (modulus=2): out[n] = in[n] * in[n-1]\r\nQPSK (modulus=4): I/Q ciftlerini complex'e cevirip diff decode\r\n\r\nChase Combining icin soft bilgiyi korur.\r\n\"\"\"\r\n\r\nimport numpy as np\r\nfrom gnuradio import gr\r\nimport pmt\r\n\r\n\r\nclass blk(gr.sync_block):\r\n    \"\"\"\r\n    Soft Differential Decoder\r\n\r\n    Differential Decoder'in soft-decision versiyonudur.\r\n    Float soft sembolleri alip soft decoded bitler uretir.\r\n\r\n    Matematiksel temel:\r\n        BPSK:  out[n] = in[n] * in[n-1]\r\n        QPSK:  y[n] = z[n] * conj(z[n-1])\r\n               z[n] = in[2n] + j*in[2n+1]\r\n               out[2n]   = Re(y[n])\r\n               out[2n+1] = Im(y[n])\r\n\r\n    Parametreler:\r\n        modulus: 2 (BPSK) veya 4 (QPSK)\r\n    \"\"\"\r\n\r\n    def __init__(self, modulus=2):\r\n        if modulus not in (2, 4):\r\n            raise ValueError(\r\n                \"Desteklenmeyen modulus: {}. \"\r\n                \"2 (BPSK) veya 4 (QPSK) kullanin.\".format(modulus)\r\n            )\r\n\r\n        self.modulus = int(modulus)\r\n\r\n        gr.sync_block.__init__(\r\n            self,\r\n            name='Soft Diff Decoder',\r\n            in_sig=[np.float32],\r\n            out_sig=[np.float32]\r\n        )\r\n\r\n        # QPSK: her seferde 2 float (I, Q cifti) islensin\r\n        if self.modulus == 4:\r\n            self.set_output_multiple(2)\r\n\r\n        # Onceki sembol referans degeri\r\n        if self.modulus == 2:\r\n            self.prev = np.float32(1.0)\r\n        else:\r\n            self.prev_complex = complex(1.0, 0.0)\r\n\r\n    def work(self, input_items, output_items):\r\n        inp = input_items[0]   # float32 dizisi\r\n        out = output_items[0]  # float32 dizisi\r\n        n = len(inp)\r\n\r\n        if n == 0:\r\n            return 0\r\n\r\n        if self.modulus == 2:\r\n            # --- BPSK: out[n] = in[n] * in[n-1] ---\r\n            extended = np.empty(n + 1, dtype=np.float32)\r\n            extended[0] = self.prev\r\n            extended[1:] = inp\r\n            # Negation: correlate_access_code_ff_ts pozitif=1\r\n            # olarak yorumlar, diff decode ise pozitif=bit0 uretir.\r\n            # Ters cevirme ile uyum saglanir.\r\n            out[:] = -(extended[1:] * extended[:-1])\r\n            self.prev = np.float32(inp[-1])\r\n\r\n        else:\r\n            # --- QPSK: I/Q ciftleri uzerinden complex diff decode ---\r\n            num_symbols = n // 2\r\n\r\n            # Soft I ve Q degerlerinden complex sembol olustur\r\n            I_vals = inp[0::2]\r\n            Q_vals = inp[1::2]\r\n            curr = (I_vals + 1j * Q_vals).astype(np.complex64)\r\n\r\n            # Onceki semboller dizisi\r\n            prev_arr = np.empty(num_symbols, dtype=np.complex64)\r\n            prev_arr[0] = self.prev_complex\r\n            prev_arr[1:] = curr[:-1]\r\n\r\n            # y[k] = curr[k] * conj(prev[k])\r\n            y = curr * np.conj(prev_arr)\r\n\r\n            # Interleaved cikis (negated for polarity match)\r\n            out[0::2] = -(y.real.astype(np.float32))\r\n            out[1::2] = -(y.imag.astype(np.float32))\r\n\r\n            self.prev_complex = complex(curr[-1])\r\n\r\n        return n\r\n"
    modulus: '2'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\r\nEmbedded Python Block: Soft Differential Decoder\r\nGiris: float32  (soft semboller, Constellation Soft Decoder'dan)\r\nCikis: float32  (soft decoded bitler, LDPC Decoder'a)\r\n\r\nBPSK (modulus=2): out[n] = in[n] * in[n-1]\r\nQPSK (modulus=4): I/Q ciftlerini complex'e cevirip diff decode\r\n\r\nChase Combining icin soft bilgiyi korur.\r\n\"\"\"\r\n\r\nimport numpy as np\r\nfrom gnuradio import gr\r\nimport pmt\r\n\r\n\r\nclass blk(gr.sync_block):\r\n    \"\"\"\r\n    Soft Differential Decoder\r\n\r\n    Differential Decoder'in soft-decision versiyonudur.\r\n    Float soft sembolleri alip soft decoded bitler uretir.\r\n\r\n    Matematiksel temel:\r\n        BPSK:  out[n] = in[n] * in[n-1]\r\n        QPSK:  y[n] = z[n] * conj(z[n-1])\r\n               z[n] = in[2n] + j*in[2n+1]\r\n               out[2n]   = Re(y[n])\r\n               out[2n+1] = Im(y[n])\r\n\r\n    Parametreler:\r\n        modulus: 2 (BPSK) veya 4 (QPSK)\r\n    \"\"\"\r\n\r\n    def __init__(self, modulus=2):\r\n        if modulus not in (2, 4):\r\n            raise ValueError(\r\n                \"Desteklenmeyen modulus: {}. \"\r\n                \"2 (BPSK) veya 4 (QPSK) kullanin.\".format(modulus)\r\n            )\r\n\r\n        self.modulus = int(modulus)\r\n\r\n        gr.sync_block.__init__(\r\n            self,\r\n            name='Soft Diff Decoder',\r\n            in_sig=[np.float32],\r\n            out_sig=[np.float32]\r\n        )\r\n\r\n        # QPSK: her seferde 2 float (I, Q cifti) islensin\r\n        if self.modulus == 4:\r\n            self.set_output_multiple(2)\r\n\r\n        # Onceki sembol referans degeri\r\n        if self.modulus == 2:\r\n            self.prev = np.float32(1.0)\r\n        else:\r\n            self.prev_complex = complex(1.0, 0.0)\r\n\r\n    def work(self, input_items, output_items):\r\n        inp = input_items[0]   # float32 dizisi\r\n        out = output_items[0]  # float32 dizisi\r\n        n = len(inp)\r\n\r\n        if n == 0:\r\n            return 0\r\n\r\n        if self.modulus == 2:\r\n            # --- BPSK: out[n] = in[n] * in[n-1] ---\r\n            extended = np.empty(n + 1, dtype=np.float32)\r\n            extended[0] = self.prev\r\n            extended[1:] = inp\r\n            # Negation: correlate_access_code_ff_ts pozitif=1\r\n            # olarak yorumlar, diff decode ise pozitif=bit0 uretir.\r\n            # Ters cevirme ile uyum saglanir.\r\n            out[:] = -(extended[1:] * extended[:-1])\r\n            self.prev = np.float32(inp[-1])\r\n\r\n        else:\r\n            # --- QPSK: I/Q ciftleri uzerinden complex diff decode ---\r\n            num_symbols = n // 2\r\n\r\n            # Soft I ve Q degerlerinden complex sembol olustur\r\n            I_vals = inp[0::2]\r\n            Q_vals = inp[1::2]\r\n            curr = (I_vals + 1j * Q_vals).astype(np.complex64)\r\n\r\n            # Onceki semboller dizisi\r\n            prev_arr = np.empty(num_symbols, dtype=np.complex64)\r\n            prev_arr[0] = self.prev_complex\r\n            prev_arr[1:] = curr[:-1]\r\n\r\n            # y[k] = curr[k] * conj(prev[k])\r\n            y = curr * np.conj(prev_arr)\r\n\r\n            # Interleaved cikis (negated for polarity match)\r\n            out[0::2] = -(y.real.astype(np.float32))\r\n            out[1::2] = -(y.imag.astype(np.float32))\r\n\r\n            self.prev_complex = complex(curr[-1])\r\n\r\n        return n\r\n"
    modulus: '2'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Decoupled BPSK NOMA SIC Aligner Block (Auto-Aligning & DBPSK Compatible)
      --------------------------------------------------------------------------
      Girişler:
        0: in_rx  (Costas Loop'tan gelen, iki kullanıcının süperpoze olduğu ham sinyal)
        1: in_tx1 (LDPC'den çözülüp BPSK modüle edilen ve 0.894 genliğiyle çarpılan User 1 sinyali)

      Çıkışlar:
        0: out_rx2 (Çıkarma işleminden sonra kalan User 2 sinyali)
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import scipy.signal

      class blk(gr.basic_block):
          """
          Decoupled BPSK NOMA SIC Aligner Block
          
          Giriş verilerini anında tüketerek dahili kuyruklara yazar, böylece
          GNU Radio zamanlayıcısının kilitlenmesini (deadlock) %100 engeller.
          """
          def __init__(self, sample_rate=200000.0, near_user_amplitude=0.864, search_window=128, payload_size=1296, payload_offset=64):
              gr.basic_block.__init__(
                  self,
                  name='Decoupled NOMA SIC Aligner',
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[np.complex64]
              )
              self.sample_rate = sample_rate
              self.near_user_amplitude = near_user_amplitude
              self.search_window = search_window
              self.payload_size = payload_size
              self.payload_offset = payload_offset

              # Dahili veri tamponları (internal buffers)
              self.buffer_rx = np.array([], dtype=np.complex64)
              self.buffer_tx1 = np.array([], dtype=np.complex64)

              # Tüketilen ve çıkışa yazılan mutlak örnek sayaçları
              self.rx_processed_abs = 0
              self.subtracted_until_abs = 0
              self.next_packet_start_abs = 0
              self.pkt_counter = 0
              self.synced = False
              self.diag_counter = 0
              # Son kestirilen User 1 genliği (dinamik normalizasyon için başlangıç değeri)
              self.last_est_amp = near_user_amplitude
              self.consecutive_skips = 0
              
              # Frame sabitleri
              self.PREAMBLE_HEADER_OFFSET = 2048  # preamble(2000) + header(48)
              self.FRAME_SIZE = 3408  # preamble(2000) + header(48) + LDPC payload(1296) + postamble(64)

          def forecast(self, noutput_items, ninputs):
              return [gr.max_int, 0] if hasattr(gr, 'max_int') else [max(1, noutput_items), 0]

          def general_work(self, input_items, output_items):
              in_rx = input_items[0]
              in_tx1 = input_items[1]
              out_rx2 = output_items[0]

              # Tanısal Loglama
              self.diag_counter += 1
              if self.diag_counter % 2000 == 1:
                  rx_mean_amp = np.mean(np.abs(in_rx)) if len(in_rx) > 0 else 0.0
                  with open("debug_sic.txt", "a") as f:
                      f.write(f"[DIAG] Call #{self.diag_counter}: in_rx_len={len(in_rx)}, mean_amp={rx_mean_amp:.6f}, synced={self.synced}, pkt={self.pkt_counter}\n")

              # 1. Gelen RX Verilerini Tampona Ekleme
              if len(in_rx) > 0:
                  self.buffer_rx = np.concatenate((self.buffer_rx, in_rx))
                  self.consume(0, len(in_rx))

              # 2. Gelen TX1 Verilerini Tampona Ekleme
              if len(in_tx1) > 0:
                  self.buffer_tx1 = np.concatenate((self.buffer_tx1, in_tx1))
                  self.consume(1, len(in_tx1))

              # 3. Tampon Aşım Koruması
              MAX_RX_BUFFER = 300000
              if len(self.buffer_rx) > MAX_RX_BUFFER:
                  trim = len(self.buffer_rx) - MAX_RX_BUFFER
                  self.buffer_rx = self.buffer_rx[trim:]
                  self.rx_processed_abs += trim
                  self.synced = False

              MAX_TX1_BUFFER = 5 * self.payload_size
              if len(self.buffer_tx1) > MAX_TX1_BUFFER:
                  self.buffer_tx1 = self.buffer_tx1[-3 * self.payload_size:]

              # 4. SIC Çıkarma ve Hizalama İşlemleri
              while len(self.buffer_tx1) >= self.payload_size:
                  tx1_chunk = self.buffer_tx1[:self.payload_size]
                  
                  # BPSK'dan DBPSK Dönüşümü
                  tx1_chunk_norm = np.sign(tx1_chunk.real)
                  tx1_chunk_diff = np.cumprod(-tx1_chunk_norm)
                  tx1_energy = np.sum(np.abs(tx1_chunk_diff)**2)
                  
                  if tx1_energy < 1e-6:
                      self.buffer_tx1 = self.buffer_tx1[self.payload_size:]
                      continue
                  
                  if not self.synced:
                      # === ENERJİ BAZLI GENLİK/AKTİVİTE ALGILAMA ===
                      rx_abs = np.abs(self.buffer_rx)
                      
                      # Gürültü eşiğini (0.15) aşan ilk indeksleri bul
                      active_indices = np.where(rx_abs > 0.15)[0]
                      
                      if len(active_indices) == 0:
                          # Henüz sinyal gelmemiş, gürültüyü kırpıp bekle
                          if len(self.buffer_rx) > 5000:
                              trim = len(self.buffer_rx) - 5000
                              self.buffer_rx = self.buffer_rx[trim:]
                              self.rx_processed_abs += trim
                          break
                      
                      signal_start_rel = active_indices[0]
                      
                      # Sinyal öncesi gürültüyü temizle
                      if signal_start_rel > 0:
                          self.buffer_rx = self.buffer_rx[signal_start_rel:]
                          self.rx_processed_abs += signal_start_rel
                          signal_start_rel = 0
                      
                      # Paket boyutu kadar verinin birikmesini bekle
                      if len(self.buffer_rx) < 5000:
                          break
                      
                      # Arama aralığı: Preamble sonu ~2016'da olacağı için 1500-2500 aralığı idealdir
                      SEARCH_START = 1500
                      SEARCH_END = 2500
                      
                      rx_search = self.buffer_rx[SEARCH_START : SEARCH_END + self.payload_size]
                      
                      if len(rx_search) < len(tx1_chunk_diff):
                          break
                      
                      corr = scipy.signal.correlate(rx_search, tx1_chunk_diff, mode='valid')
                      
                      if len(corr) == 0:
                          break
                      
                      best_idx = np.argmax(np.abs(corr))
                      best_val = corr[best_idx]
                      estimated_amp = np.abs(best_val) / tx1_energy
                      
                      if estimated_amp >= 0.15:
                          phase_offset = np.angle(best_val)
                          amplitude_scale = max(0.05, min(2.0, estimated_amp))
                          self.last_est_amp = amplitude_scale
                          
                          payload_start_rel = SEARCH_START + best_idx
                          payload_start_abs = self.rx_processed_abs + payload_start_rel
                          
                          # Girişimi sembol bazında dinamik faz takibi (DDPT) ile çıkar
                          rx_payload = self.buffer_rx[payload_start_rel : payload_start_rel + self.payload_size]
                          raw_phase = rx_payload * tx1_chunk_diff
                          window_size = 63  # Arttırıldı: User 2 sızıntısını ve faz gürültüsünü azaltır
                          kernel = np.ones(window_size) / window_size
                          smoothed_phase = np.convolve(raw_phase, kernel, mode='same')
                          # Kenar bozulmalarını engelle
                          half = window_size // 2
                          smoothed_phase[:half] = smoothed_phase[half]
                          smoothed_phase[-half:] = smoothed_phase[-half-1]
                          
                          interference = tx1_chunk_diff * smoothed_phase
                          self.buffer_rx[payload_start_rel : payload_start_rel + self.payload_size] -= interference
                          
                          self.next_packet_start_abs = payload_start_abs - self.PREAMBLE_HEADER_OFFSET + self.FRAME_SIZE
                          self.synced = True
                          self.pkt_counter += 1
                          
                          self.subtracted_until_abs = max(self.subtracted_until_abs, 
                              payload_start_abs - self.PREAMBLE_HEADER_OFFSET + self.FRAME_SIZE)
                          
                          self.buffer_tx1 = self.buffer_tx1[self.payload_size:]
                          
                          print(f"[SIC] Energy-Synced Packet #{self.pkt_counter} @ abs={payload_start_abs}, Phase={phase_offset:.3f}, Est={estimated_amp:.3f}")
                          with open("debug_sic.txt", "a") as f:
                              f.write(f"[SIC] Energy-Synced Packet #{self.pkt_counter} @ abs={payload_start_abs}, Phase={phase_offset:.3f}, Est={estimated_amp:.3f}\n")
                          continue
                      else:
                          # Hizalama başarısız ise 500 sembol kaydırıp tekrar dene
                          self.buffer_rx = self.buffer_rx[500:]
                          self.rx_processed_abs += 500
                          continue
                  
                  else:
                      # === SENKRONİZE MOD: Dar arama penceresi ===
                      expected_abs = self.next_packet_start_abs + self.PREAMBLE_HEADER_OFFSET
                      expected_rel = expected_abs - self.rx_processed_abs
                      
                      if expected_rel < -128:
                          self.synced = False
                          print(f"[SIC] Packet #{self.pkt_counter} is in the past (expected_rel={expected_rel}), skipping")
                          with open("debug_sic.txt", "a") as f:
                              f.write(f"[SIC] Packet #{self.pkt_counter} is in the past (expected_rel={expected_rel}), skipping\n")
                          self.pkt_counter += 1
                          self.next_packet_start_abs += self.FRAME_SIZE
                          self.buffer_tx1 = self.buffer_tx1[self.payload_size:]
                          continue
                      
                      search_start = max(0, expected_rel - 128)
                      search_end = expected_rel + 128
                      
                      if len(self.buffer_rx) < search_end + self.payload_size:
                          break
                      
                      rx_search = self.buffer_rx[search_start : search_end + self.payload_size]
                      
                      if len(rx_search) < len(tx1_chunk_diff) or len(rx_search) == 0:
                          self.synced = False
                          break  # RX verisi yetersiz, zamanlayıcıyı engellememek için döngüden çık
                      
                      corr = scipy.signal.correlate(rx_search, tx1_chunk_diff, mode='valid')
                      
                      if len(corr) == 0:
                          self.synced = False
                          break  # RX verisi yetersiz, zamanlayıcıyı engellememek için döngüden çık
                      
                      best_idx = np.argmax(np.abs(corr))
                      best_val = corr[best_idx]
                      estimated_amp = np.abs(best_val) / tx1_energy
                      
                      payload_start_rel = search_start + best_idx
                      payload_start_abs = self.rx_processed_abs + payload_start_rel
                      phase_offset = np.angle(best_val)
                      
                      if estimated_amp >= 0.15:
                          self.consecutive_skips = 0
                          amplitude_scale = max(0.05, min(2.0, estimated_amp))
                          self.last_est_amp = amplitude_scale
                          
                          # Girişimi sembol bazında dinamik faz takibi (DDPT) ile çıkar
                          rx_payload = self.buffer_rx[payload_start_rel : payload_start_rel + self.payload_size]
                          raw_phase = rx_payload * tx1_chunk_diff
                          window_size = 63  # Arttırıldı: User 2 sızıntısını ve faz gürültüsünü azaltır
                          kernel = np.ones(window_size) / window_size
                          smoothed_phase = np.convolve(raw_phase, kernel, mode='same')
                          # Kenar bozulmalarını engelle
                          half = window_size // 2
                          smoothed_phase[:half] = smoothed_phase[half]
                          smoothed_phase[-half:] = smoothed_phase[-half-1]
                          
                          interference = tx1_chunk_diff * smoothed_phase
                          self.buffer_rx[payload_start_rel : payload_start_rel + self.payload_size] -= interference
                          
                          self.pkt_counter += 1
                          self.next_packet_start_abs = payload_start_abs - self.PREAMBLE_HEADER_OFFSET + self.FRAME_SIZE
                          self.subtracted_until_abs = max(self.subtracted_until_abs,
                              payload_start_abs - self.PREAMBLE_HEADER_OFFSET + self.FRAME_SIZE)
                          
                          self.buffer_tx1 = self.buffer_tx1[self.payload_size:]
                          
                          shift = payload_start_rel - expected_rel
                          if self.pkt_counter % 20 == 0:
                              print(f"[SIC] Packet #{self.pkt_counter} OK, Shift={shift}, Phase={phase_offset:.3f}, Est={estimated_amp:.3f}")
                          continue
                      else:
                          # Gelişmiş Zamanlama Kurtarma: User 1 alıcısının paket kaçırıp kaçırmadığını kontrol et.
                          # Eğer mevcut referans bloğu, buffer_rx içindeki bir sonraki paketle eşleşiyorsa,
                          # alıcı paket kaçırmıştır. Bu durumda RX tamponunu 1 paket kaydırarak hizalamayı düzeltiriz.
                          lookahead_start = expected_rel + self.FRAME_SIZE - 128
                          lookahead_end = expected_rel + self.FRAME_SIZE + 128
                          la_success = False
                          if len(self.buffer_rx) >= lookahead_end + self.payload_size:
                              rx_lookahead = self.buffer_rx[lookahead_start : lookahead_end + self.payload_size]
                              corr_lookahead = scipy.signal.correlate(rx_lookahead, tx1_chunk_diff, mode='valid')
                              if len(corr_lookahead) > 0:
                                  best_idx_la = np.argmax(np.abs(corr_lookahead))
                                  best_val_la = corr_lookahead[best_idx_la]
                                  est_amp_la = np.abs(best_val_la) / tx1_energy
                                  if est_amp_la >= 0.15:
                                      # Bir sonraki slotta eşleşme bulundu! Mevcut RX paketini atla.
                                      print(f"[SIC] User 1 referans paket kaybı algılandı (#{self.pkt_counter})! RX tamponu kaydırılıyor.")
                                      self.next_packet_start_abs += self.FRAME_SIZE
                                      self.subtracted_until_abs = max(self.subtracted_until_abs, self.next_packet_start_abs)
                                      la_success = True
                                      
                          if la_success:
                              # Referans paketini tüketmeden döngüyü tekrar çalıştırarak hizalamayı sına
                              continue
                          
                          # Gerçek senkronizasyon kaybı veya sönümleme (lookahead da başarısız)
                          self.pkt_counter += 1
                          self.next_packet_start_abs += self.FRAME_SIZE
                          self.subtracted_until_abs = max(self.subtracted_until_abs, self.next_packet_start_abs)
                          self.buffer_tx1 = self.buffer_tx1[self.payload_size:]
                          self.consecutive_skips += 1
                          
                          if self.pkt_counter % 100 == 0:
                              print(f"[SIC] Low corr packet #{self.pkt_counter} (Est={estimated_amp:.3f}), skipping")
                          
                          if self.consecutive_skips >= 3:
                              self.synced = False
                              self.consecutive_skips = 0
                              print(f"[SIC] Senkronizasyon Kayboldu (Ardışık 3 başarısız paket, #{self.pkt_counter}). Enerji-senk moduna geçiliyor.")
                          continue

              # 5. Çıkışa Güvenli Örnekleri Yazma
              safe_to_output = self.subtracted_until_abs - self.rx_processed_abs
              safe_to_output = min(safe_to_output, len(self.buffer_rx))
              safe_to_output = max(0, safe_to_output)

              n_out = len(out_rx2)
              limit = min(safe_to_output, n_out)

              if limit > 0:
                  # Dinamik normalizasyon: Statik 2.0 yerine, kestirilen User 1 genliğine oranla ölçekle.
                  # Bu işlem USRP'deki kanal sönümlemesini (kanal kaybını) kompanse eder ve Soft Diff
                  # Decoder'a gönderilen LLR değerlerinin karesel çökmesini önler.
                  norm_factor = 2.0 / max(0.05, self.last_est_amp)
                  out_rx2[:limit] = self.buffer_rx[:limit] * norm_factor
                  self.buffer_rx = self.buffer_rx[limit:]
                  self.rx_processed_abs += limit
                  return limit
              else:
                  return 0
    near_user_amplitude: '0.085'
    payload_offset: '64'
    payload_size: '1296'
    sample_rate: samp_rate
    search_window: '32'
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: ldpc_dec
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: fec_extended_decoder_0_0
  id: fec_extended_decoder
  parameters:
    decoder_list: ldpc_dec_2
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_0_0_0
  id: fec_extended_encoder
  parameters:
    encoder_list: ldpc_enc
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: note_0
  id: note
  parameters:
    note: Receiver
  states: {}
- name: note_1
  id: note
  parameters:
    note: user 1
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: user 2
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[1, 0, 4, 3]'
    label1: Real
    label2: Imag
    name: Received Samples
    size: '1024'
    srate: samp_rate
    tr_delay: '0.0'
    tr_tag: ''
    type: complex
    ymax: '1.0'
    ymin: '-1.0'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[5, 0, 4, 3]'
    label1: Real
    label2: Imag
    name: Recovered Symbols
    size: '256'
    srate: samp_rate/sps
    style2: '3'
    tr_delay: '0.0'
    tr_level: '0.01'
    type: complex
    update_time: '0.1'
    ymax: '1.0'
    ymin: '-1.0'
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[9, 0, 4, 3]'
    label1: Real
    label2: Imag
    name: USER 2
    size: '256'
    srate: samp_rate/sps
    style2: '3'
    tr_delay: '0.0'
    tr_level: '0.01'
    type: complex
    update_time: '0.1'
    ymax: '1.0'
    ymin: '-1.0'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 868e6
    gain0: '42'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: channel
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: recovery
  states: {}
- name: virtual_sink_3_0
  id: virtual_sink
  parameters:
    stream_id: recovery_2
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: rx_payload
  states: {}
- name: virtual_sink_4_0
  id: virtual_sink
  parameters:
    stream_id: rx_payload_2
  states: {}
- name: virtual_sink_6
  id: virtual_sink
  parameters:
    stream_id: ldpc_rx
  states: {}
- name: virtual_sink_6_0
  id: virtual_sink
  parameters:
    stream_id: user_2
  states: {}
- name: virtual_sink_6_1
  id: virtual_sink
  parameters:
    stream_id: ldpc_rx_2
  states: {}
- name: virtual_sink_7
  id: virtual_sink
  parameters:
    stream_id: user_2_sub
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: channel
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: recovery_2
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: recovery
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: rx_payload
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: rx_payload_2
  states: {}
- name: virtual_source_8
  id: virtual_source
  parameters:
    stream_id: ldpc_rx
  states: {}
- name: virtual_source_8_0
  id: virtual_source
  parameters:
    stream_id: ldpc_rx_2
  states: {}
- name: virtual_source_9
  id: virtual_source
  parameters:
    stream_id: user_2_sub
  states: {}

connections:
- [blocks_multiply_const_vxx_0_0_0, '0', virtual_sink_7, '0']
- [blocks_repack_bits_bb_1, '0', virtual_sink_6, '0']
- [blocks_repack_bits_bb_1_1, '0', virtual_sink_6_1, '0']
- [blocks_tagged_stream_multiply_length_0_1, '0', digital_additive_scrambler_xx_0_0, '0']
- [blocks_tagged_stream_multiply_length_0_1, '0', fec_extended_encoder_0_0_0, '0']
- [blocks_tagged_stream_multiply_length_0_1_0, '0', digital_additive_scrambler_xx_0_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_2, '0']
- [digital_additive_scrambler_xx_0_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_additive_scrambler_xx_0_0, '0', virtual_sink_6_0, '0']
- [digital_additive_scrambler_xx_0_0_0, '0', blocks_repack_bits_bb_1_1, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [digital_constellation_soft_decoder_cf_0, '0', epy_block_0, '0']
- [digital_constellation_soft_decoder_cf_0_0, '0', epy_block_0_0, '0']
- [digital_corr_est_cc_0, '0', virtual_sink_3_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', virtual_sink_4, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', virtual_sink_4_0, '0']
- [digital_costas_loop_cc_0, '0', digital_corr_est_cc_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_1_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_3, '0']
- [digital_crc32_bb_1, '0', blocks_file_sink_0, '0']
- [digital_crc32_bb_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_crc32_bb_1_0, '0', blocks_file_sink_0_0, '0']
- [digital_crc32_bb_1_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [epy_block_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [epy_block_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [epy_block_1, '0', digital_constellation_soft_decoder_cf_0_0, '0']
- [epy_block_1, '0', qtgui_time_sink_x_1_0_0, '0']
- [fec_extended_decoder_0, '0', blocks_tagged_stream_multiply_length_0_1, '0']
- [fec_extended_decoder_0_0, '0', blocks_tagged_stream_multiply_length_0_1_0, '0']
- [fec_extended_encoder_0_0_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [filter_fft_rrc_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [pdu_tagged_stream_to_pdu_0_0, pdus, blocks_message_debug_0_0, print]
- [uhd_usrp_source_0, '0', blocks_throttle2_0, '0']
- [virtual_source_1, '0', filter_fft_rrc_filter_0, '0']
- [virtual_source_1_0_0, '0', epy_block_1, '0']
- [virtual_source_2, '0', digital_constellation_soft_decoder_cf_0, '0']
- [virtual_source_3, '0', fec_extended_decoder_0, '0']
- [virtual_source_3_0, '0', fec_extended_decoder_0_0, '0']
- [virtual_source_8, '0', digital_crc32_bb_1, '0']
- [virtual_source_8_0, '0', digital_crc32_bb_1_0, '0']
- [virtual_source_9, '0', epy_block_1, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
