options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: hdr_format
  id: variable_header_format_default
  parameters:
    access_code: '"1010101011110000101010101111000010101010111100001010101011110000"'
    bps: '8'
    comment: 'ARQ Header Format - 32 bits: seq_num(16) + ack_nack(1) + retrans_count(3) + reserved(12)'
    threshold: '1'
  states: {}
- name: hdr_format_rx
  id: variable
  parameters:
    comment: RX Header Format - ARQ compatible with payload length in reserved field
    value: digital.header_format_counter("1010101011110000101010101111000010101010111100001010101011110000", 1, 8)
  states: {}
- name: header_len
  id: variable
  parameters:
    comment: ARQ Header length in bits (32 bits = 4 bytes)
    value: '32'
  states: {}
- name: ldpc_dec_def
  id: variable_ldpc_decoder_def
  parameters:
    file: C:\Users\Armagan\Documents\GitHub\BitirmeProjesi\packet\n_0300_k_0152_gap_03.alist
    max_iter: '50'
    ndim: '0'
  states: {}
- name: ldpc_enc_def
  id: variable_ldpc_encoder_def
  parameters:
    file: C:\Users\Armagan\Documents\GitHub\BitirmeProjesi\packet\n_0300_k_0152_gap_03.alist
    ndim: '0'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '110'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Armagan\Documents\GitHub\BitirmeProjesi\packet\son.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Armagan\Documents\GitHub\BitirmeProjesi\packet\giris.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '110'
    n: '114'
    offset: '0'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '-2.0'
    type: float
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 300.0/152.0
    lengthtagname: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '4'
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '1010101011110000101010101111000010101010111100001010101011110000'
    tagname: packet_len
    threshold: '8'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.005'
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: '32'
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"payload symbols"'
    output_symbols: 'False'
    samp_rate: samp_rate
    special_tags: ()
    timing_tag_key: '"rx_time"'
    trigger_tag_key: '"packet_len"'
    type: byte
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '4'
    ted_gain: '0.1'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt


      class arq_header_parser(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='arq_header_parser',
                  in_sig=[np.byte],
                  out_sig=[]
              )
              self.message_port_register_out(pmt.intern('header_data'))
              self.buf = []
              self.payload_len = 110  # Fixed payload length in bytes

          def work(self, input_items, output_items):
              inp = input_items[0]
              self.buf.extend(inp.tolist())
              # 32 bits = 4 bytes
              while len(self.buf) >= 4:
                  bits = self.buf[:4]
                  self.buf = self.buf[4:]
                  # Parse ARQ header format (32 bits = 4 bytes):
                  # Bits 0-15: Sequence Number (16 bits)
                  # Bit 16: ACK/NACK Flag (1 bit)
                  # Bits 17-19: Retransmit Count (3 bits)
                  # Bits 20-31: Reserved (12 bits)

                  # Convert 4 bytes to 32 bits
                  all_bits = []
                  for byte in bits:
                      for i in range(7, -1, -1):
                          all_bits.append((byte >> i) & 1)

                  seq_num = 0
                  for i in range(16):
                      seq_num = (seq_num << 1) | all_bits[i]
                  ack_nack = all_bits[16] & 1
                  retrans_count = 0
                  for i in range(17, 20):
                      retrans_count = (retrans_count << 1) | all_bits[i]
                  # Use fixed payload length for demux
                  msg = pmt.make_dict()
                  msg = pmt.dict_add(msg, pmt.intern('payload symbols'), pmt.from_long(self.payload_len))
                  msg = pmt.dict_add(msg, pmt.intern('seq_num'), pmt.from_long(seq_num))
                  msg = pmt.dict_add(msg, pmt.intern('ack_nack'), pmt.from_long(ack_nack))
                  msg = pmt.dict_add(msg, pmt.intern('retrans_count'), pmt.from_long(retrans_count))
                  self.message_port_pub(pmt.intern('header_data'), msg)
              return len(inp)
    comment: ARQ Header Parser - extracts seq_num, ack_nack, retrans_count
  states: {}
- name: epy_block_seq_num
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt


      class sequence_number_generator(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='sequence_number_generator',
                  in_sig=[np.byte],
                  out_sig=[np.byte]
              )
              self.seq_num = 0
              self.pkt_len = 110
              self.pkt_count = 0
              self.message_port_register_out(pmt.intern('seq_num_info'))

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              n_items = min(len(inp), len(out))
              for i in range(n_items):
                  out[i] = inp[i]
              # Check if we have a complete packet
              self.pkt_count += n_items
              if self.pkt_count >= self.pkt_len:
                  self.pkt_count = 0
                  # Send sequence number info via message
                  msg = pmt.make_dict()
                  msg = pmt.dict_add(msg, pmt.intern('seq_num'), pmt.from_long(self.seq_num))
                  self.message_port_pub(pmt.intern('seq_num_info'), msg)
                  self.seq_num = (self.seq_num + 1) % 65536
              return n_items
    comment: Sequence Number Generator - adds 16-bit sequence number to each packet
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: ldpc_dec_def
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: ldpc_enc_def
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"demux çıkış"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"correlate access code çıkış"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"correlate access code giriş"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_char_to_float_0_2, '0', blocks_add_const_vxx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', channels_channel_model_0, '0']
- [blocks_multiply_const_vxx_1, '0', fec_extended_decoder_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_repack_bits_bb_0_0, '0', digital_constellation_modulator_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', digital_scrambler_bb_0, '0']
- [blocks_repack_bits_bb_0_0_0_0, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_tagged_stream_multiply_length_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_throttle2_0, '0', epy_block_seq_num, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [channels_channel_model_0, '0', virtual_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_char_to_float_0_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', digital_header_payload_demux_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_sink_x_0, '0']
- [digital_crc32_bb_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [digital_descrambler_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_header_payload_demux_0, '0', epy_block_0, '0']
- [digital_header_payload_demux_0, '1', blocks_char_to_float_0, '0']
- [digital_header_payload_demux_0, '1', blocks_char_to_float_0_2, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_repack_bits_bb_0_0_0_0, '0']
- [digital_scrambler_bb_0, '0', fec_extended_encoder_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [epy_block_0, header_data, digital_header_payload_demux_0, header_data]
- [epy_block_seq_num, '0', blocks_stream_to_tagged_stream_0, '0']
- [fec_extended_decoder_0, '0', digital_descrambler_bb_0, '0']
- [fec_extended_encoder_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [virtual_source_0, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
