options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: hdr_format
  id: variable_header_format_default
  parameters:
    access_code: '1010101011110000101010101111000010101010111100001010101011110000'
    bps: '8'
    threshold: '1'
  states: {}
- name: hdr_format_rx
  id: variable
  parameters:
    value: digital.header_format_default("", 0, 1)
  states: {}
- name: ldpc_dec
  id: variable_ldpc_decoder_def
  parameters:
    file: C:\Users\Armagan\Documents\GitHub\BitirmeProjesi\packet\n_0300_k_0152_gap_03.alist
    max_iter: '50'
    ndim: '0'
  states: {}
- name: ldpc_enc
  id: variable_ldpc_encoder_def
  parameters:
    file: C:\Users\Armagan\Documents\GitHub\BitirmeProjesi\packet\n_0300_k_0152_gap_03.alist
    ndim: '0'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '91'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Armagan\Documents\GitHub\BitirmeProjesi\packet\son.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Armagan\Documents\GitHub\BitirmeProjesi\packet\giris.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-2'
    type: float
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '91'
    type: byte
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 300.0/152.0
    lengthtagname: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '1010101011110000101010101111000010101010111100001010101011110000'
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: '32'
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"payload symbols"'
    output_symbols: 'False'
    samp_rate: samp_rate
    special_tags: ()
    timing_tag_key: '"rx_time"'
    trigger_tag_key: '"packet_len"'
    type: byte
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt


      class custom_header_parser(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='custom_header_parser',
                  in_sig=[np.byte],
                  out_sig=[]
              )
              self.message_port_register_out(pmt.intern('header_data'))
              self.buf = []

          def work(self, input_items, output_items):
              inp = input_items[0]
              self.buf.extend(inp.tolist())
              while len(self.buf) >= 32:
                  bits = self.buf[:32]
                  self.buf = self.buf[32:]
                  len1 = 0
                  for i in range(16):
                      len1 = (len1 << 1) | (bits[i] & 1)
                  len2 = 0
                  for i in range(16, 32):
                      len2 = (len2 << 1) | (bits[i] & 1)
                  if len1 == len2 and 0 < len1 < 10000:
                      msg = pmt.make_dict()
                      msg = pmt.dict_add(msg, pmt.intern('payload symbols'), pmt.from_long(len1))
                      self.message_port_pub(pmt.intern('header_data'), msg)
                  else:
                      self.message_port_pub(pmt.intern('header_data'), pmt.PMT_F)
              return len(inp)
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: ldpc_dec
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: ldpc_enc
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"header/payload demux çıkış"'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"correlater çıkış"'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"correlater giriş"'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"fec decoder çıkış"'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_1_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_1_1, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_char_to_float_1_2, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', fec_extended_decoder_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_scrambler_bb_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', virtual_sink_0, '0']
- [blocks_repack_bits_bb_0_0_0_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_tagged_stream_multiply_length_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_1_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_char_to_float_1_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', digital_header_payload_demux_0, '0']
- [digital_crc32_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_descrambler_bb_0, '0', blocks_repack_bits_bb_0_0_0_0, '0']
- [digital_header_payload_demux_0, '0', blocks_char_to_float_1, '0']
- [digital_header_payload_demux_0, '0', epy_block_0, '0']
- [digital_header_payload_demux_0, '1', blocks_char_to_float_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_repack_bits_bb_0_0, '0']
- [digital_scrambler_bb_0, '0', fec_extended_encoder_0, '0']
- [epy_block_0, header_data, digital_header_payload_demux_0, header_data]
- [fec_extended_decoder_0, '0', blocks_char_to_float_1_2, '0']
- [fec_extended_decoder_0, '0', digital_descrambler_bb_0, '0']
- [fec_extended_encoder_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [virtual_source_0, '0', blocks_unpack_k_bits_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
