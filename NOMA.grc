options:
  parameters:
    author: Armağan Bi
    generate_options: qt_gui
    id: NOMA
    output_language: python
    title: NOMA
  states: {}

blocks:
- name: constel
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0, 1, 1, 1]'
    label: Freq Offset
    start: '-0.25'
    step: '0.001'
    stop: '0.25'
    value: '0.01'
  states: {}
- name: hdr
  id: variable
  parameters:
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: ldpc_dec
  id: variable_ldpc_decoder_def
  parameters:
    file: C:\Users\Armagan\Documents\GitHub\BitirmeProjesi\n_1296_k_0648_ieee.alist
    max_iter: '50'
    ndim: '0'
  states: {}
- name: ldpc_enc
  id: variable_ldpc_encoder_def
  parameters:
    file: C:\Users\Armagan\Documents\GitHub\BitirmeProjesi\n_1296_k_0648_ieee.alist
    ndim: '0'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0, 0, 1, 1]'
    label: Noise
    start: '0.0'
    step: '0.01'
    stop: '2.0'
    value: '0.1'
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '77'
  states: {}
- name: postamble_size
  id: variable
  parameters:
    value: '8'
  states: {}
- name: preamble_size
  id: variable
  parameters:
    value: '250'
  states: {}
- name: preamble_syms
  id: variable
  parameters:
    value: '[complex(1 - 2 * ((b >> (7 - i)) & 1), 0) for b in [0xc0, 0xaf] * 4 for i in range(8)]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0, 2, 1, 1]'
    label: Time Scale
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.0001'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: bpsk_receive.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: bpsk_receive_2.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: bpsk_transmit.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: bpsk_transmit_2.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.447'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.894'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.894'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_1
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_1
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: payload_size
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: preamble_size
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: postamble_size
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: postamble_size
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0_0_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: preamble_size
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: payload_size
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '2.0'
    lengthtagname: '"packet_len"'
    type: byte
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '2.0'
    lengthtagname: '"packet_len"'
    type: byte
  states: {}
- name: blocks_tagged_stream_multiply_length_0_1
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '0.5'
    lengthtagname: '"packet_len"'
    type: byte
  states: {}
- name: blocks_tagged_stream_multiply_length_0_1_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '0.5'
    lengthtagname: '"packet_len"'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '4'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '4'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: items
    maximum: '512'
    samples_per_second: '8000'
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    limit: items
    maximum: '512'
    samples_per_second: '8000'
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Preamble
    repeat: 'True'
    type: byte
    vector: '[0xc0, 0xaf]'
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    comment: Postamble
    repeat: 'True'
    type: byte
    vector: '[0xc0, 0xaf]'
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    comment: Postamble
    repeat: 'True'
    type: byte
    vector: '[0xc0, 0xaf]'
  states: {}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    comment: Preamble
    repeat: 'True'
    type: byte
    vector: '[0xc0, 0xaf]'
  states: {}
- name: channels_channel_model_1
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_additive_scrambler_xx_0
  id: digital_additive_scrambler_xx
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: '7'
    mask: '0x8A'
    reset_tag_key: '"packet_len"'
    seed: '0x7F'
    type: byte
  states: {}
- name: digital_additive_scrambler_xx_0_0
  id: digital_additive_scrambler_xx
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: '7'
    mask: '0x8A'
    reset_tag_key: '"packet_len"'
    seed: '0x7F'
    type: byte
  states: {}
- name: digital_additive_scrambler_xx_0_0_0
  id: digital_additive_scrambler_xx
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: '7'
    mask: '0x8A'
    reset_tag_key: '"packet_len"'
    seed: '0x7F'
    type: byte
  states: {}
- name: digital_additive_scrambler_xx_0_1
  id: digital_additive_scrambler_xx
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: '7'
    mask: '0x8A'
    reset_tag_key: '"packet_len"'
    seed: '0x7F'
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1.0+0j, 1.0+0j]'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: constel
    npwr: '-1'
  states: {}
- name: digital_constellation_soft_decoder_cf_0_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: constel
    npwr: '-1'
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: len(preamble_syms)-1
    sps: '1'
    symbols: preamble_syms
    threshold: '0.7'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    tagname: packet_len
    threshold: '0'
    type: float
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    tagname: packet_len
    threshold: '0'
    type: float
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: len(constel.points())
    w: 2*3.14/100
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: packet_len
    packed: 'True'
  states: {}
- name: digital_crc32_bb_1_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: packet_len
    packed: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr
    len_tag_key: packet_len
  states: {}
- name: digital_protocol_formatter_bb_0_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr
    len_tag_key: packet_len
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: constel.base()
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '0.1'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\r\nEmbedded Python Block: Soft Differential Decoder\r\nGiris: float32  (soft semboller, Constellation Soft Decoder'dan)\r\nCikis: float32  (soft decoded bitler, LDPC Decoder'a)\r\n\r\nBPSK (modulus=2): out[n] = in[n] * in[n-1]\r\nQPSK (modulus=4): I/Q ciftlerini complex'e cevirip diff decode\r\n\r\nChase Combining icin soft bilgiyi korur.\r\n\"\"\"\r\n\r\nimport numpy as np\r\nfrom gnuradio import gr\r\nimport pmt\r\n\r\n\r\nclass blk(gr.sync_block):\r\n    \"\"\"\r\n    Soft Differential Decoder\r\n\r\n    Differential Decoder'in soft-decision versiyonudur.\r\n    Float soft sembolleri alip soft decoded bitler uretir.\r\n\r\n    Matematiksel temel:\r\n        BPSK:  out[n] = in[n] * in[n-1]\r\n        QPSK:  y[n] = z[n] * conj(z[n-1])\r\n               z[n] = in[2n] + j*in[2n+1]\r\n               out[2n]   = Re(y[n])\r\n               out[2n+1] = Im(y[n])\r\n\r\n    Parametreler:\r\n        modulus: 2 (BPSK) veya 4 (QPSK)\r\n    \"\"\"\r\n\r\n    def __init__(self, modulus=2):\r\n        if modulus not in (2, 4):\r\n            raise ValueError(\r\n                \"Desteklenmeyen modulus: {}. \"\r\n                \"2 (BPSK) veya 4 (QPSK) kullanin.\".format(modulus)\r\n            )\r\n\r\n        self.modulus = int(modulus)\r\n\r\n        gr.sync_block.__init__(\r\n            self,\r\n            name='Soft Diff Decoder',\r\n            in_sig=[np.float32],\r\n            out_sig=[np.float32]\r\n        )\r\n\r\n        # QPSK: her seferde 2 float (I, Q cifti) islensin\r\n        if self.modulus == 4:\r\n            self.set_output_multiple(2)\r\n\r\n        # Onceki sembol referans degeri\r\n        if self.modulus == 2:\r\n            self.prev = np.float32(1.0)\r\n        else:\r\n            self.prev_complex = complex(1.0, 0.0)\r\n\r\n    def work(self, input_items, output_items):\r\n        inp = input_items[0]   # float32 dizisi\r\n        out = output_items[0]  # float32 dizisi\r\n        n = len(inp)\r\n\r\n        if n == 0:\r\n            return 0\r\n\r\n        if self.modulus == 2:\r\n            # --- BPSK: out[n] = in[n] * in[n-1] ---\r\n            extended = np.empty(n + 1, dtype=np.float32)\r\n            extended[0] = self.prev\r\n            extended[1:] = inp\r\n            # Negation: correlate_access_code_ff_ts pozitif=1\r\n            # olarak yorumlar, diff decode ise pozitif=bit0 uretir.\r\n            # Ters cevirme ile uyum saglanir.\r\n            out[:] = -(extended[1:] * extended[:-1])\r\n            self.prev = np.float32(inp[-1])\r\n\r\n        else:\r\n            # --- QPSK: I/Q ciftleri uzerinden complex diff decode ---\r\n            num_symbols = n // 2\r\n\r\n            # Soft I ve Q degerlerinden complex sembol olustur\r\n            I_vals = inp[0::2]\r\n            Q_vals = inp[1::2]\r\n            curr = (I_vals + 1j * Q_vals).astype(np.complex64)\r\n\r\n            # Onceki semboller dizisi\r\n            prev_arr = np.empty(num_symbols, dtype=np.complex64)\r\n            prev_arr[0] = self.prev_complex\r\n            prev_arr[1:] = curr[:-1]\r\n\r\n            # y[k] = curr[k] * conj(prev[k])\r\n            y = curr * np.conj(prev_arr)\r\n\r\n            # Interleaved cikis (negated for polarity match)\r\n            out[0::2] = -(y.real.astype(np.float32))\r\n            out[1::2] = -(y.imag.astype(np.float32))\r\n\r\n            self.prev_complex = complex(curr[-1])\r\n\r\n        return n\r\n"
    modulus: '2'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\r\nEmbedded Python Block: Soft Differential Decoder\r\nGiris: float32  (soft semboller, Constellation Soft Decoder'dan)\r\nCikis: float32  (soft decoded bitler, LDPC Decoder'a)\r\n\r\nBPSK (modulus=2): out[n] = in[n] * in[n-1]\r\nQPSK (modulus=4): I/Q ciftlerini complex'e cevirip diff decode\r\n\r\nChase Combining icin soft bilgiyi korur.\r\n\"\"\"\r\n\r\nimport numpy as np\r\nfrom gnuradio import gr\r\nimport pmt\r\n\r\n\r\nclass blk(gr.sync_block):\r\n    \"\"\"\r\n    Soft Differential Decoder\r\n\r\n    Differential Decoder'in soft-decision versiyonudur.\r\n    Float soft sembolleri alip soft decoded bitler uretir.\r\n\r\n    Matematiksel temel:\r\n        BPSK:  out[n] = in[n] * in[n-1]\r\n        QPSK:  y[n] = z[n] * conj(z[n-1])\r\n               z[n] = in[2n] + j*in[2n+1]\r\n               out[2n]   = Re(y[n])\r\n               out[2n+1] = Im(y[n])\r\n\r\n    Parametreler:\r\n        modulus: 2 (BPSK) veya 4 (QPSK)\r\n    \"\"\"\r\n\r\n    def __init__(self, modulus=2):\r\n        if modulus not in (2, 4):\r\n            raise ValueError(\r\n                \"Desteklenmeyen modulus: {}. \"\r\n                \"2 (BPSK) veya 4 (QPSK) kullanin.\".format(modulus)\r\n            )\r\n\r\n        self.modulus = int(modulus)\r\n\r\n        gr.sync_block.__init__(\r\n            self,\r\n            name='Soft Diff Decoder',\r\n            in_sig=[np.float32],\r\n            out_sig=[np.float32]\r\n        )\r\n\r\n        # QPSK: her seferde 2 float (I, Q cifti) islensin\r\n        if self.modulus == 4:\r\n            self.set_output_multiple(2)\r\n\r\n        # Onceki sembol referans degeri\r\n        if self.modulus == 2:\r\n            self.prev = np.float32(1.0)\r\n        else:\r\n            self.prev_complex = complex(1.0, 0.0)\r\n\r\n    def work(self, input_items, output_items):\r\n        inp = input_items[0]   # float32 dizisi\r\n        out = output_items[0]  # float32 dizisi\r\n        n = len(inp)\r\n\r\n        if n == 0:\r\n            return 0\r\n\r\n        if self.modulus == 2:\r\n            # --- BPSK: out[n] = in[n] * in[n-1] ---\r\n            extended = np.empty(n + 1, dtype=np.float32)\r\n            extended[0] = self.prev\r\n            extended[1:] = inp\r\n            # Negation: correlate_access_code_ff_ts pozitif=1\r\n            # olarak yorumlar, diff decode ise pozitif=bit0 uretir.\r\n            # Ters cevirme ile uyum saglanir.\r\n            out[:] = -(extended[1:] * extended[:-1])\r\n            self.prev = np.float32(inp[-1])\r\n\r\n        else:\r\n            # --- QPSK: I/Q ciftleri uzerinden complex diff decode ---\r\n            num_symbols = n // 2\r\n\r\n            # Soft I ve Q degerlerinden complex sembol olustur\r\n            I_vals = inp[0::2]\r\n            Q_vals = inp[1::2]\r\n            curr = (I_vals + 1j * Q_vals).astype(np.complex64)\r\n\r\n            # Onceki semboller dizisi\r\n            prev_arr = np.empty(num_symbols, dtype=np.complex64)\r\n            prev_arr[0] = self.prev_complex\r\n            prev_arr[1:] = curr[:-1]\r\n\r\n            # y[k] = curr[k] * conj(prev[k])\r\n            y = curr * np.conj(prev_arr)\r\n\r\n            # Interleaved cikis (negated for polarity match)\r\n            out[0::2] = -(y.real.astype(np.float32))\r\n            out[1::2] = -(y.imag.astype(np.float32))\r\n\r\n            self.prev_complex = complex(curr[-1])\r\n\r\n        return n\r\n"
    modulus: '2'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Decoupled BPSK NOMA SIC Aligner Block (Auto-Aligning & DBPSK Compatible)
      --------------------------------------------------------------------------
      Bu dosya GNU Radio Companion (GRC) içerisindeki gömülü Python Bloğuna
      (Embedded Python Block) kopyalayıp yapıştırmanız için hazırlanmıştır.

      Girişler:
        0: in_rx  (Costas Loop'tan gelen, iki kullanıcının süperpoze olduğu ham sinyal)
        1: in_tx1 (LDPC'den çözülüp BPSK modüle edilen ve 0.894 genliğiyle çarpılan User 1 sinyali)

      Çıkışlar:
        0: out_rx2 (Çıkarma işleminden sonra kalan User 2 sinyali)
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import scipy.signal

      class blk(gr.basic_block):
          """
          Decoupled BPSK NOMA SIC Aligner Block

          Giriş verilerini anında tüketerek dahili kuyruklara yazar, böylece
          GNU Radio zamanlayıcısının kilitlenmesini (deadlock) %100 engeller.
          DBPSK uyumlu diferansiyel kod çözücü öncesi tam şablon eşleme ile
          mükemmel girişim çıkarma ve sıfır sızıntı sağlar.
          """
          def __init__(self, sample_rate=200000.0, near_user_amplitude=0.894, search_window=128, payload_size=1296, payload_offset=64):
              gr.basic_block.__init__(
                  self,
                  name='Decoupled NOMA SIC Aligner',
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[np.complex64]
              )
              self.sample_rate = sample_rate
              self.near_user_amplitude = near_user_amplitude
              self.search_window = search_window
              self.payload_size = payload_size
              self.payload_offset = payload_offset

              # Dahili veri tamponları (internal buffers)
              self.buffer_rx = np.array([], dtype=np.complex64)
              self.buffer_tx1 = np.array([], dtype=np.complex64)

              # Bekleyen paketlerin mutlak başlangıç indeksleri (absolute indices)
              self.pending_payload_starts = []

              # Tüketilen ve çıkışa yazılan mutlak örnek sayaçları
              self.rx_processed_abs = 0
              self.pkt_counter = 0

          def forecast(self, noutput_items, ninputs):
              # Zamanlayıcı kilidini önlemek için girdi gereksinimlerini 0 yapıyoruz.
              return [0] * ninputs

          def general_work(self, input_items, output_items):
              in_rx = input_items[0]
              in_tx1 = input_items[1]
              out_rx2 = output_items[0]

              # 1. Gelen RX Verilerini Tampona Ekleme ve Etiket Tarama
              if len(in_rx) > 0:
                  self.buffer_rx = np.concatenate((self.buffer_rx, in_rx))

                  # time_est, packet_len veya corr_est etiketlerini yakala
                  tags = self.get_tags_in_window(0, 0, len(in_rx))
                  for tag in tags:
                      tag_key = pmt.to_python(tag.key)
                      if tag_key in ["time_est", "packet_len", "corr_est"]:
                          # Etiketin mutlak offset değeri
                          tag_abs_idx = tag.offset
                          # Gerçek payload başlangıcı
                          payload_start_abs = tag_abs_idx + self.payload_offset
                          
                          if payload_start_abs not in self.pending_payload_starts:
                              self.pending_payload_starts.append(payload_start_abs)
                  
                  # RX girişini anında tüket (consume) - Kilitlenmeyi önleyen en kritik adım
                  self.consume(0, len(in_rx))

              # 2. Gelen TX1 Verilerini Tampona Ekleme
              if len(in_tx1) > 0:
                  self.buffer_tx1 = np.concatenate((self.buffer_tx1, in_tx1))
                  self.consume(1, len(in_tx1))

              # 3. Tampon Kilitlenme ve Aşım Koruması (Buffer Overflow / Packet Timeout Safeguard)
              TIMEOUT_SAMPLES = self.payload_size + 20000
              while len(self.pending_payload_starts) > 0:
                  start_rel = self.pending_payload_starts[0] - self.rx_processed_abs
                  if len(self.buffer_rx) - start_rel > TIMEOUT_SAMPLES:
                      print(f"[SIC Aligner] WARNING: Packet at abs_idx {self.pending_payload_starts[0]} timed out (User 1 decoding failed). Skipping subtraction.")
                      self.pending_payload_starts.pop(0)
                  else:
                      break

              # TX1 Tampon Aşım Koruması
              MAX_TX1_BUFFER = 3 * self.payload_size
              if len(self.buffer_tx1) > MAX_TX1_BUFFER:
                  excess = len(self.buffer_tx1) - MAX_TX1_BUFFER
                  self.buffer_tx1 = self.buffer_tx1[excess:]

              # 4. SIC Çıkarma İşlemleri (Packet Extraction and Subtraction)
              while len(self.pending_payload_starts) > 0:
                  payload_start_abs = self.pending_payload_starts[0]
                  start_rel = payload_start_abs - self.rx_processed_abs

                  # Arama sınırlarını tanımla (Arama penceresi kadar geriye ve ileriye esneyebiliriz)
                  search_left = self.search_window
                  search_right = self.search_window

                  if start_rel - search_left < 0:
                      search_left = start_rel

                  # RX veya TX1 tamponu henüz hazır değilse bekle
                  if start_rel + self.payload_size + search_right > len(self.buffer_rx):
                      break
                  if len(self.buffer_tx1) < self.payload_size:
                      break

                  # A. Genişletilmiş Arama Alanı ve TX1 Verisini Al
                  rx_search_chunk = self.buffer_rx[start_rel - search_left : start_rel + self.payload_size + search_right]
                  tx1_chunk = self.buffer_tx1[:self.payload_size]

                  # B. DBPSK Dönüşümü (Diferansiyel Kodlama)
                  # in_tx1'den gelen BPSK sembollerini DBPSK alanına dönüştürmek için kümülatif çarpım uyguluyoruz.
                  # Bu adım uzyuşmazlığı giderir ve korelasyonun tavan yapmasını sağlar!
                  # Not: in_tx1 genlikle çarpılmış olduğundan, kümülatif çarpımın sönümlenmesini önlemek için 
                  # önce sembolleri normalize ediyoruz (+1 ve -1 seviyelerine getiriyoruz).
                  tx1_chunk_norm = np.sign(tx1_chunk.real)
                  tx1_chunk_diff = np.cumprod(-tx1_chunk_norm)

                  # C. Otomatik Kayma Kestirimi (Auto-Timing via Valid Sliding Cross-Correlation)
                  corr = scipy.signal.correlate(rx_search_chunk, tx1_chunk_diff, mode='valid')
                  
                  if len(corr) > 0:
                      best_idx = np.argmax(np.abs(corr))
                      best_val = corr[best_idx]
                      # Gerçek kayma miktarı (start_rel'e göre)
                      shift = best_idx - search_left
                  else:
                      shift = 0
                      best_val = 0.0

                  # D. Genlik ve Faz Kestirimi
                  tx1_energy = np.sum(np.abs(tx1_chunk_diff)**2)
                  if tx1_energy > 1e-6:
                      estimated_amp = np.abs(best_val) / tx1_energy
                  else:
                      estimated_amp = self.near_user_amplitude

                  # E. Dinamik Eşleşme Kontrolü (Packet Matcher / Drop Protection)
                  if estimated_amp < 0.4 * self.near_user_amplitude:
                      # Korelasyon düşükse bu bir öncül-etiket fazlalığıdır, silme yapmadan geçiyoruz.
                      self.pending_payload_starts.pop(0)
                      continue

                  self.pkt_counter += 1

                  # Statik genlik kullanımı (Over-subtraction engelleniyor!)
                  amplitude_scale = self.near_user_amplitude
                  phase_offset = np.angle(best_val)

                  # F. Tam Hizalanmış Girişim Sinyalini Sentezle
                  interference_signal = tx1_chunk_diff * amplitude_scale * np.exp(1j * phase_offset)

                  # G. Tam Hizalanmış Çıkarma İşlemi (SIC Subtraction - Sıfır Sızıntı!)
                  payload_start_rel = start_rel + shift
                  self.buffer_rx[payload_start_rel : payload_start_rel + self.payload_size] -= interference_signal

                  # TX1 tamponunun kullanılan kısmını serbest bırak
                  self.buffer_tx1 = self.buffer_tx1[self.payload_size:]
                  # İşlenen paketi listeden çıkar
                  self.pending_payload_starts.pop(0)

                  print(f"[SIC Aligner] Packet #{self.pkt_counter} Subtracted! Shift: {shift} symbols, Phase: {phase_offset:.3f} rad, Amp (Static): {amplitude_scale:.3f} (Est: {estimated_amp:.3f})")

              # 5. Çıkışa Güvenli Örnekleri Yazma (Streaming Output)
              if len(self.pending_payload_starts) > 0:
                  safe_to_output = self.pending_payload_starts[0] - self.rx_processed_abs
              else:
                  safe_to_output = len(self.buffer_rx)

              # ValueError hatasını engelleyen en kritik sınır kontrolü
              safe_to_output = min(safe_to_output, len(self.buffer_rx))
              safe_to_output = max(0, safe_to_output)
              
              n_out = len(out_rx2)
              limit = min(safe_to_output, n_out)

              if limit > 0:
                  out_rx2[:limit] = self.buffer_rx[:limit]
                  self.buffer_rx = self.buffer_rx[limit:]
                  self.rx_processed_abs += limit
                  return limit
              else:
                  return 0
    near_user_amplitude: '0.864'
    payload_offset: '64'
    payload_size: '1296'
    sample_rate: samp_rate
    search_window: '32'
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: ldpc_dec
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: fec_extended_decoder_0_0
  id: fec_extended_decoder
  parameters:
    decoder_list: ldpc_dec
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: ldpc_enc
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_0_0
  id: fec_extended_encoder
  parameters:
    encoder_list: ldpc_enc
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_0_0_0
  id: fec_extended_encoder
  parameters:
    encoder_list: ldpc_enc
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: note_0
  id: note
  parameters:
    note: Receiver
  states: {}
- name: note_1
  id: note
  parameters:
    note: Far user
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: near user
  states: {}
- name: note_2
  id: note
  parameters:
    note: Channel simulation
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[1, 0, 4, 3]'
    label1: Real
    label2: Imag
    name: Received Samples
    size: '1024'
    srate: samp_rate
    tr_delay: '0.0'
    tr_tag: ''
    type: complex
    ymax: '1.0'
    ymin: '-1.0'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[5, 0, 4, 3]'
    label1: Real
    label2: Imag
    name: Recovered Symbols
    size: '256'
    srate: samp_rate/sps
    style2: '3'
    tr_delay: '0.0'
    tr_level: '0.01'
    type: complex
    update_time: '0.1'
    ymax: '1.0'
    ymin: '-1.0'
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[9, 0, 4, 3]'
    label1: Real
    label2: Imag
    name: USER 2
    size: '256'
    srate: samp_rate/sps
    style2: '3'
    tr_delay: '0.0'
    tr_level: '0.01'
    type: complex
    update_time: '0.1'
    ymax: '1.0'
    ymin: '-1.0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_packet_1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: header_1
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: header_2
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: tx_packet_2
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: transmit
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: channel
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: recovery
  states: {}
- name: virtual_sink_3_0
  id: virtual_sink
  parameters:
    stream_id: recovery_2
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: rx_payload
  states: {}
- name: virtual_sink_4_0
  id: virtual_sink
  parameters:
    stream_id: rx_payload_2
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: ldpc_payload_1
  states: {}
- name: virtual_sink_5_0
  id: virtual_sink
  parameters:
    stream_id: ldpc_payload_2
  states: {}
- name: virtual_sink_6
  id: virtual_sink
  parameters:
    stream_id: ldpc_rx
  states: {}
- name: virtual_sink_6_0
  id: virtual_sink
  parameters:
    stream_id: user_2
  states: {}
- name: virtual_sink_6_1
  id: virtual_sink
  parameters:
    stream_id: ldpc_rx_2
  states: {}
- name: virtual_sink_7
  id: virtual_sink
  parameters:
    stream_id: user_2_sub
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx_packet_2
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: tx_packet_1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: channel
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: recovery_2
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: recovery
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: rx_payload
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: rx_payload_2
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: transmit
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: header_1
  states: {}
- name: virtual_source_5_0
  id: virtual_source
  parameters:
    stream_id: header_2
  states: {}
- name: virtual_source_7
  id: virtual_source
  parameters:
    stream_id: ldpc_payload_1
  states: {}
- name: virtual_source_7_0
  id: virtual_source
  parameters:
    stream_id: ldpc_payload_2
  states: {}
- name: virtual_source_8
  id: virtual_source
  parameters:
    stream_id: ldpc_rx
  states: {}
- name: virtual_source_8_0
  id: virtual_source
  parameters:
    stream_id: ldpc_rx_2
  states: {}
- name: virtual_source_9
  id: virtual_source
  parameters:
    stream_id: user_2_sub
  states: {}

connections:
- [blocks_add_xx_0, '0', virtual_sink_1, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_stream_to_tagged_stream_0_0_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_tag_gate_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_tag_gate_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', virtual_sink_7, '0']
- [blocks_repack_bits_bb_0, '0', digital_additive_scrambler_xx_0, '0']
- [blocks_repack_bits_bb_0_0, '0', virtual_sink_5, '0']
- [blocks_repack_bits_bb_0_0_0, '0', virtual_sink_5_0, '0']
- [blocks_repack_bits_bb_0_1, '0', digital_additive_scrambler_xx_0_1, '0']
- [blocks_repack_bits_bb_1, '0', virtual_sink_6, '0']
- [blocks_repack_bits_bb_1_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_repack_bits_bb_1_0_0, '0', digital_protocol_formatter_bb_0_0, '0']
- [blocks_repack_bits_bb_1_1, '0', virtual_sink_6_1, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0_0, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0_0_0, '0', blocks_tagged_stream_mux_0, '3']
- [blocks_stream_to_tagged_stream_0_0_0_0_0_0, '0', blocks_tagged_stream_mux_0_0, '3']
- [blocks_stream_to_tagged_stream_0_0_0_0_1, '0', blocks_tagged_stream_mux_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0_1, '0', digital_crc32_bb_0_0, '0']
- [blocks_tag_gate_0, '0', blocks_add_xx_0, '1']
- [blocks_tag_gate_0_0, '0', blocks_add_xx_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', blocks_repack_bits_bb_1_0, '0']
- [blocks_tagged_stream_multiply_length_0_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [blocks_tagged_stream_multiply_length_0_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [blocks_tagged_stream_multiply_length_0_1, '0', digital_additive_scrambler_xx_0_0, '0']
- [blocks_tagged_stream_multiply_length_0_1, '0', fec_extended_encoder_0_0_0, '0']
- [blocks_tagged_stream_multiply_length_0_1_0, '0', digital_additive_scrambler_xx_0_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', virtual_sink_0_1, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0_0_0_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_stream_to_tagged_stream_0_0_0_0_0, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_stream_to_tagged_stream_0_0_0_0_0_0, '0']
- [blocks_vector_source_x_0_1, '0', blocks_stream_to_tagged_stream_0_0_0_0_1, '0']
- [channels_channel_model_1, '0', qtgui_time_sink_x_0_0, '0']
- [channels_channel_model_1, '0', virtual_sink_2, '0']
- [digital_additive_scrambler_xx_0, '0', fec_extended_encoder_0, '0']
- [digital_additive_scrambler_xx_0_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_additive_scrambler_xx_0_0, '0', virtual_sink_6_0, '0']
- [digital_additive_scrambler_xx_0_0_0, '0', blocks_repack_bits_bb_1_1, '0']
- [digital_additive_scrambler_xx_0_1, '0', fec_extended_encoder_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_constellation_soft_decoder_cf_0, '0', epy_block_0, '0']
- [digital_constellation_soft_decoder_cf_0_0, '0', epy_block_0_0, '0']
- [digital_corr_est_cc_0, '0', virtual_sink_3_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', virtual_sink_4, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', virtual_sink_4_0, '0']
- [digital_costas_loop_cc_0, '0', digital_corr_est_cc_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_1_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_3, '0']
- [digital_crc32_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_repack_bits_bb_0_1, '0']
- [digital_crc32_bb_1, '0', blocks_file_sink_0, '0']
- [digital_crc32_bb_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_crc32_bb_1_0, '0', blocks_file_sink_0_0, '0']
- [digital_crc32_bb_1_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [digital_protocol_formatter_bb_0, '0', virtual_sink_0_0, '0']
- [digital_protocol_formatter_bb_0_0, '0', virtual_sink_0_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [epy_block_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [epy_block_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [epy_block_1, '0', digital_constellation_soft_decoder_cf_0_0, '0']
- [epy_block_1, '0', qtgui_time_sink_x_1_0_0, '0']
- [fec_extended_decoder_0, '0', blocks_tagged_stream_multiply_length_0_1, '0']
- [fec_extended_decoder_0_0, '0', blocks_tagged_stream_multiply_length_0_1_0, '0']
- [fec_extended_encoder_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [fec_extended_encoder_0_0, '0', blocks_tagged_stream_multiply_length_0_0, '0']
- [fec_extended_encoder_0_0_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [filter_fft_rrc_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [pdu_tagged_stream_to_pdu_0_0, pdus, blocks_message_debug_0_0, print]
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_0_0, '0', digital_constellation_modulator_0_0, '0']
- [virtual_source_1, '0', filter_fft_rrc_filter_0, '0']
- [virtual_source_1_0_0, '0', epy_block_1, '0']
- [virtual_source_2, '0', digital_constellation_soft_decoder_cf_0, '0']
- [virtual_source_3, '0', fec_extended_decoder_0, '0']
- [virtual_source_3_0, '0', fec_extended_decoder_0_0, '0']
- [virtual_source_4, '0', channels_channel_model_1, '0']
- [virtual_source_5, '0', blocks_tagged_stream_mux_0, '1']
- [virtual_source_5_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [virtual_source_7, '0', blocks_tagged_stream_mux_0, '2']
- [virtual_source_7_0, '0', blocks_tagged_stream_mux_0_0, '2']
- [virtual_source_8, '0', digital_crc32_bb_1, '0']
- [virtual_source_8_0, '0', digital_crc32_bb_1_0, '0']
- [virtual_source_9, '0', epy_block_1, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
